# Keil uVision project Template.uvprojx, settings and files
target APM32F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: APM32F407IG Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AMP32F407IG_MINI
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F40X,APM32F407_MINI
  c include: ..\..\Application\Include;..\..\Firmware\APM32F4xx_StdPeriphDriver\Include;..\..\Firmware\CMSIS\Include;..\..\Firmware\CMSIS\Geehy\APM32F4xx\Include;..\..\Board\Include;..\..\Utilities;..\..\BSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../../Firmware/CMSIS/Geehy/APM32F4xx/Source/: system_apm32f4xx.c
    ../../Firmware/CMSIS/Geehy/APM32F4xx/Source/arm/: startup_apm32f40x.s
  group StdPeriphDriver
    ../../Firmware/APM32F4xx_StdPeriphDriver/Source/: apm32f4xx_adc.c apm32f4xx_can.c apm32f4xx_comp.c apm32f4xx_crc.c apm32f4xx_cryp.c apm32f4xx_cryp_aes.c apm32f4xx_cryp_des.c apm32f4xx_cryp_tdes.c apm32f4xx_dac.c apm32f4xx_dbgmcu.c apm32f4xx_dci.c apm32f4xx_dma.c apm32f4xx_dmc.c apm32f4xx_eint.c apm32f4xx_fmc.c apm32f4xx_gpio.c apm32f4xx_hash.c apm32f4xx_hash_md5.c apm32f4xx_hash_sha1.c apm32f4xx_i2c.c apm32f4xx_iwdt.c apm32f4xx_misc.c apm32f4xx_pmu.c apm32f4xx_qspi.c apm32f4xx_rcm.c apm32f4xx_rng.c apm32f4xx_rtc.c apm32f4xx_sdio.c apm32f4xx_smc.c apm32f4xx_spi.c apm32f4xx_syscfg.c apm32f4xx_tmr.c apm32f4xx_usart.c apm32f4xx_usb.c apm32f4xx_wwdt.c
  group Application
    ../../Application/Source/: apm32f4xx_int.c main.c interrupts.c
  group Board
    ../../Board/Source/: Board.c bsp_delay.c bsp_key.c
  group Utilities
    ../../Utilities/: simple_profiler.c systick.c
  group BSP
    ../../BSP/Source/: bsp_nvic.c
